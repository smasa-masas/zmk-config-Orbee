## config/boards/shields/Orbee/Kconfig.shield
```kconfig
config SHIELD_ORBEE_R
    def_bool $(shields_list_contains,Orbee_R)

config SHIELD_Orbee_L
    def_bool $(shields_list_contains,Orbee_L)
```
